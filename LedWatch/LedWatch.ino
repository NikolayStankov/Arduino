#include <RTCx.h>
#include <Wire.h>
#include "Ledwatch.h"
#include "LedArrays.h"


void setup() {
pinMode (IRsensor,INPUT);
pinMode(latchPin,OUTPUT);
pinMode(dataPin,OUTPUT);
pinMode(clockPin,OUTPUT);

DefineTimeValues();

    //RTC SETUP
    if (F_CPU > 8000000UL)
    Serial.begin(115200);
  else
    Serial.begin(9600);
  Wire.begin();

  // Autoprobe to find a real-time clock.
  if (rtc.autoprobe()) {
    // Found something, hopefully a clock.
    Serial.print("Autoprobe found ");
    Serial.print(rtc.getDeviceName());
    Serial.print(" at 0x");
    Serial.println(rtc.getAddress(), HEX);
  }
  else {
    // Nothing found at any of the addresses listed.
    Serial.println("No RTCx found, cannot continue");
    while (1)
      ;
  }

  // Enable the battery backup. This happens by default on the DS1307
  // but needs to be enabled on the MCP7941x.
  rtc.enableBatteryBackup();

  // rtc.clearPowerFailFlag();

  // Ensure the oscillator is running.
  rtc.startClock();

  if (rtc.getDevice() == RTCx::MCP7941x) {
    Serial.print("Calibration: ");
    Serial.println(rtc.getCalibration(), DEC);
    // rtc.setCalibration(-127);
  }

  rtc.setSQW(RTCx::freq4096Hz);
}


void loop() {
 // Hour=12;
 // Minute=10;
/*
if(Hour<=12){
  Hour++;
  }
  if (Hour>12){
  Hour=1;
  }
*/ 
/* 
  if(Minute<=12){
  Minute++;
  }
  if (Minute>12){
  Minute=1;
  }
  */
  RTC();
  dispMinutes(Minute);
 dispHours(Hour); 
  
  IRsense = digitalRead(IRsensor);
  
 if(IRsense==HIGH)
 {
  digitalWrite(led,HIGH);
  //time="detected";
  //Serial.println(time);
 }
 else {
  digitalWrite(led,LOW);
 } 
}






